# Repository kazushinjo/Serrasoid_TRX_29M

File README.md (part):

# Serrasoid TRX 29M

29MHz 帯 FM トランシーバ（出力 約 5W）。送信の変調に、1940 年代後半の放送用 FM 送信機で使われた**セラゾイド変調（Serrasoid）**を汎用 IC で再現する。

> 部品はリード部品（第 1 混合の NJM2594V だけ表面実装 SSOP8。SA612 が製造中止のため）。

> **状態: 回路図 Ver 1.2 作成済み**（[回路図 PDF](kicad/Serrasoid_TRX_回路図.pdf)・[部品表](kicad/BOM.md)・[購入用部品表](kicad/bom_purchase.csv)）。基板 Ver 1.2（170 × 150mm）は配置・配線まで（スプリアス対策で逓倍を ×16 にし段間同調と PLL を追加、DRC エラー 0、[基板チェック](docs/基板チェック.md)、[部品実装図](docs/Serrasoid_TRX_部品実装図.pdf)・[部品配置図 A3](kicad/Serrasoid_TRX_部品配置図.pdf)）。スケッチ（[firmware/Serrasoid_TRX](firmware/Serrasoid_TRX/)、コンパイル確認のみ）・LCD 画面の背景と作り方は作成済み、製造データ（ガーバー）は出力済み（[kicad/production](kicad/production/)）、LCD の画面データ（.HMI）はこれから。実機未製作

回路図は 1 枚（A0）。機能ブロック（電源・制御・セラゾイド変調・逓倍・PLL・送信音声・送信RF・受信）ごとに枠で囲み、ブロックの中もブロックの間も、信号・電源ともすべて線で結線している（ネットラベルは使わない）。電源の名前（+13V8・+5VT・TX8V など）は、その電源の出どころ（レギュレータの出力など）に電源記号を 1 つ置いて示す。GND だけは GND 記号でつなぐ。

## 動作原理

### 1. セラゾイド変調（位相変調を作る）

セラゾイド（Serrasoid）は「のこぎり波（serrated）」から来た名前で、のこぎり波としきい値の交点のタイミングで位相を変える方式です。

1. **基準クロック**: Si5351 の CLK0 から 1.83125MHz（周期 546ns）を直接出し、その立ち上がりで 74HCT123 の 2 回路目が幅 約 50〜100ns のリセットパルスを作ります。
2. **のこぎり波**: 2SA1015 の定電流源（約 300µA）で 68pF を充電すると、電圧は時間に比例して上がります（傾き 約 3.4V/µs）。リセットパルスで 2N7000 が放電し、1 周期ごとに 0V に戻ります。
3. **比較**: 2SA1015 2 個の差動対（Q9・Q10、電流 約 2.3mA）が、のこぎり波と「しきい値 = 直流の中心（約 0.85V）＋ 音声」を比べます。のこぎり波がしきい値を超えると、Q9 が切れて出力 COMP_N が約 2.3V から 0V に下がります。しきい値が ΔV 上がると、交点は Δt ＝ ΔV ÷（傾き）だけ遅れます。傾きが一定なので、**タイミングのずれ（＝位相のずれ）が音声電圧に比例**します。
4. **パルス整形**: 74HCT123 の 1 回路目が交点（COMP_N の立ち下がり）で幅 273ns（デューティ 50%）のパルスを出します。この方形波 PM_OUT の両方のエッジが音声で前後する、位相変調（PM）された 1.83125MHz です。

位相のずれは Δφ ＝ 2π × Δt ÷ T（T ＝ 546ns）。たとえばしきい値が 1mV 動くと Δt ≒ 0.29ns、Δφ ≒ 3.4mrad です。

### 2. PM と FM の関係（積分器を入れない理由）

位相を φ(t) ＝ β sin(2π fm t) と動かすと、周波数は f ＝ (1/2π) dφ/dt だけずれるので、偏移は Δf ＝ β × fm になります。PM では同じ大きさの音なら β が一定なので、**偏移は音の高さに比例**（6dB/oct で増える）します。

放送用のセラゾイド送信機は、音声を先に積分（1/f）して PM を FM に直していました。アマチュア無線の FM 機は、送信で 6dB/oct のプリエンファシス（×f）をかけ、受信でディエンファシスで戻すのが標準です。「積分（1/f）× プリエンファシス（×f）」は打ち消し合うので、**積分器を入れずに PM のまま送れば、プリエンファシス付き FM と同じ**になり、市販の FM 機で自然な音で聞こえます。

### 3. 逓倍（周波数も位相も 16 倍に）

変調部での位相のずれは小さい（3kHz で ±5kHz に必要な ±1.67rad の 1/16、±0.104rad）ので、逓倍して周波数と偏移を同時に上げます。

- **XOR 逓倍**: 入力 x と、x を入力周期の 1/4 だけ遅らせたもの（RC ＋ 74AC14）を XOR に入れると、入力の両方のエッジで幅 1/4 周期のパルスが出て、周波数が 2 倍になります。これを 4 段重ねて 1.83 → 3.66 → 7.33 → 14.65 → 29.30MHz（×16）。
- **位相も 16 倍**: 逓倍はエッジのタイミングのずれ Δt をそのまま運び、周期が 1/2 になるごとに同じ Δt が 2 倍の位相になります。29.3MHz での位相のずれは 16 × Δφ、偏移は Δf ＝ 16 × Δφ × fm です。
- **段間同調**: 遅延が 1/4 周期からずれる（74AC14 のしきい値や部品のばらつきで数 ns）と、出力のデューティがくずれて入力周波数の成分（分数調波）が残り、次の段がそれを運んで基準周波数おきの側帯波（スプリアス）になります。そこで段 1〜3 の出力を LC の並列共振（Q 約 5）で正弦波にし、自己バイアスの 74HCU04 で**平均値を境に矩形へ戻す**ことで、デューティを 50% にそろえます（分数調波 約 −16dB）。

### 4. PLL 追従フィルタ（スプリアスを落とす）

×16 の出力にはまだ ±1.83MHz おきの側帯波（計算で −11dBc 程度）が残ります。29.3MHz の VCO をこの信号に位相同期させ、VCO の出力を送信に使います。

- **位相周波数比較**: 74AC74 の 2 個の D-FF を ×16 の出力と VCO でそれぞれセットし、両方 High になったら 74AC00 で両方クリアします。進んでいる側に、位相差に比例した幅のパルスが出ます（周波数が違っても正しい向きに引き込む）。
- **ループフィルタ**: MCP6002 の差動積分器で UP − DN を積分し、VCO の制御電圧 VT（0〜5V）を作ります。ループ帯域 約 37kHz、ζ ≒ 0.7。
- **VCO**: 74HCU04 のピアース（コルピッツ）型 LC 発振。1N4007 の接合容量を可変容量に使い、VT で約 0.8MHz 動かします。
- **効き方**: PLL はループ帯域より遅い位相の動きにだけ追従します。音声の位相変調（〜3kHz）はそのまま VCO に移り、±1.83MHz の側帯波は VCO に移りません（約 −77dB）。計算では、送信 BPF・LPF と合わせてアンテナ端の側帯波は最悪 −99dBc です（[図](docs/images/spurious_calc_0-300MHz.png)）。

### 5. 電力増幅

VCO の出力（3 回路を 330Ω ずつで合成）→ 送信 BPF（29MHz 複同調、1pF 結合）→ 2N2222A（バッファ）→ IRF510（ドライバ、約 0.5W）→ IRF510 × 2 のプッシュプル（ファイナル、約 5W）。入力トランス（BN43-202 1:1、2 次側センタータップにバイアス）で 2 個のゲートを逆相に振り、出力トランス（BN43-202、1 次 2 回センタータップ・2 次 3 回）でドレイン間 約 22Ω を 50Ω に合わせます。29MHz・13.8V では IRF510 の利得が下がるので、出力は 5W 前後の見込みです（2026-10-29 に製造終了の RD06HHF1・RD16HHF1 から変更）。プッシュプルなので偶数次の高調波が打ち消し合います が要るので、BN43-202 の 1:6.25 トランス（一次 2 回・二次 5 回）で 50Ω に合わせ、7 次チェビシェフ LPF（fc 約 32MHz）で高調波を落とします。出力の一部を容量分割 ＋ 1N60 で検波し、XIAO が送信出力を表示します。

### 6. 受信（ダブルスーパー）

1. **RF**: 29MHz 複同調 BPF → 2N3819（ソース接地）で増幅。
2. **第 1 混合**: NJM2594V（ダブルバランスドミキサ）で、Si5351 の CLK1（受信周波数 − 10.7MHz、29.3MHz なら 18.6MHz）と混ぜて 10.7MHz に。変換利得が 0dB なので、2SC1815 で約 19dB 増幅します。
3. **第 1 IF**: 10.7MHz 水晶フィルタ（帯域 15kHz）で隣のチャンネルを落とします。
4. **第 2 IF・検波**: MC3361 の中で 10.245MHz の水晶発振と混ぜて 455kHz にし、セラミックフィルタ → リミッタ → クオドラチャ検波（CDBM455 ディスクリミネータ）で音声に戻します。
5. **低周波**: ディエンファシス（470µs）→ VOL → LM386（約 0.5W）。

### 7. スケルチと S メーター

- **ノイズスケルチ**: FM は信号が強いほど、検波出力の高い周波数のノイズが減ります（クワイティング）。検波出力の 7kHz 以上を MCP6002 で約 47 倍に増幅して倍電圧検波し、その電圧を XIAO が読みます。電圧が設定（SQL 1〜9）より下がると信号ありと判断し、Q4 で LM386 の入力を GND から離して音を出します。
- **S メーター**: MC3361 には受信電界強度（RSSI）の出力がないので、10.7MHz 水晶フィルタの後ろを 2.2kΩ で取り出し、2SC1815 の同調増幅（約 26dB）→ AD8307 で測ります。AD8307 は対数増幅器で、入力電力 1dB ごとに出力が 25mV 変わります。これを ADS1115（I2C の 16 ビット ADC）で読み、S 単位（6dB ＝ S1 つ）に直してアナログメーターに表示します。

### 8. 周波数の決め方と送受切替

| | 計算 | 29.300MHz のとき |
|---|---|---|
| 送信 CLK0 | 送信周波数 ÷ 16 | 1.83125MHz（×16 で 29.3MHz） |
| 受信 CLK1 | 受信周波数 − 10.7MHz | 18.600MHz |

- チャンネルは Si5351 の設定を変えるだけです（出力 10kHz ＝ CLK0 625Hz）。PLL は ×16 の出力に追従します。
- **送受切替**: PTT を押すと、XIAO が CLK1 を止め → リレー G5V-2 を切り替え（1 極目でアンテナ、2 極目で 8V を TX8V へ）→ 15ms 待って CLK0 を出します。送信系のバイアスは TX8V のときだけかかります。受信中は CLK0 を止め、VCO の入力も 2SC1815 で GND に落とすので、自局の信号が受信に回り込みません。
- **スキャン**: 10kHz ずつ周波数を変え、1 チャンネル 200ms ずつスケルチの電圧を見て、信号があれば止まります。

## 全体構成

```
                    XIAO ESP32C3（チャンネル・PTT・表示）
                         │ I2C
                       Si5351
             CLK0: 1.83125MHz          CLK1: 18.600MHz（受信局発 = 29.300 − 10.7）
                  │                         │
【送信】          ↓                          │
 マイク → IDC・LPF → セラゾイド変調（1.83125MHz）│
                  ↓                         │
  XOR 逓倍 ×16（段間同調）→ PLL（VCO）→ 29.300MHz│
                  ↓                         │
       BPF → 2N2222A → IRF510 → IRF510×2 P.P.（約 5W）→ 7 次 LPF → 送受切替リレー → ANT
                                                              │
【受信】                                                       ↓
 BPF → 2N3819（RF 増幅）→ NJM2594（混合）←── CLK1
            ↓ 10.7MHz 増幅（2SC1815）
   10.7MHz 水晶フィルタ（15kHz 幅）→ MC3361（455kHz・検波・スケルチ）→ LM386 → SP
```

## 仕様

数値は設計値・計算値です（実機は未製作で、測定はしていません）。

### 送信

| 項目 | 値 |
|---|---|
| 周波数 | 29.000〜29.700MHz（呼出 29.300MHz）。ステップ 1k・5k・10k・100kHz（既定 10kHz） |
| 電波型式 | F3E（FM） |
| 送信出力 | 約 5W（13.8V、50Ω。29MHz では IRF510 の利得が下がるための見込み値） |
| 最大周波数偏移 | ±5kHz（3kHz の音で。半固定 VR で合わせる） |
| 変調方式 | セラゾイド変調（1.83125MHz で PM）→ XOR 逓倍 ×16（段間同調つき）→ PLL 追従フィルタ（VCO 29.3MHz）。積分器なしの PM ＝ 6dB/oct のプリエンファシス付き FM と同じ特性 |
| 音声 | エレクトレットマイク、IDC（±0.6V クリップ）、3kHz LPF |
| 電力増幅 | 2N2222A（バッファ）→ IRF510（ドライバ）→ IRF510 × 2 プッシュプル（ファイナル）→ BN43-202 で 1:2.25 → 7 次チェビシェフ LPF（fc 約 32MHz） |
| スプリアス（計算） | 逓倍のずれによる側帯波 最悪 −99dBc（部品のばらつき 200 通り）、高調波 最大 −85dBc（3 倍、PA の高調波は仮定）。[図](docs/images/spurious_calc_0-300MHz.png)。規格は 50mW 以下かつ −50dBc（5W で −13dBm） |
| 送信の切り替え | PTT → リレー（G5V-2）→ 15ms 後に変調基準を出す。29.000〜29.700MHz の外では送信しない |

### 受信

| 項目 | 値 |
|---|---|
| 方式 | ダブルスーパー（第 1 IF 10.7MHz、第 2 IF 455kHz。第 2 変換以降は MC3361） |
| RF | 29MHz 複同調 BPF → 2N3819（ソース接地） |
| 第 1 混合・局発 | NJM2594V（DBM）、局発は Si5351 の CLK1（受信周波数 − 10.7MHz、下側） |
| 選択度 | 10.7MHz 水晶フィルタ（帯域 15kHz）＋ 455kHz セラミックフィルタ |
| 復調 | MC3361（クオドラチャ検波、CDBM455 ディスクリミネータ）、ディエンファシス 470µs |
| 低周波出力 | LM386 約 0.5W（8Ω、内蔵スピーカー 5cm または外部スピーカー） |
| スケルチ | ノイズスケルチ（7kHz 以上のノイズを検波、XIAO が判定してミュート）。深さ SQL 0〜9 |
| S メーター | AD8307（対数増幅）で 10.7MHz 水晶フィルタの後ろの強さを測る。計算で S2〜S9＋40 程度。アナログメーター表示 |
| スキャン | 29.000〜29.700MHz を 10kHz ずつ。スケルチが開いたら止まり、信号が消えて 3 秒で再開 |

### 制御・表示

| 項目 | 値 |
|---|---|
| マイコン | Seeed Studio XIAO ESP32C3（スケッチ: [firmware/Serrasoid_TRX](firmware/Serrasoid_TRX/)） |
| 発振 | Si5351A モジュール（秋月 AE-Si5351A）。CLK0 = 変調基準（送信周波数 ÷ 16）、CLK1 = 受信局発 |
| 表示器 | Nextion NX4832T035（3.5 インチ 480 × 320、PSN_TRX と同じ）。TJC4832T135 も可。周波数・ステップ・アナログ S メーター（送信中は出力 W）・RX / TX / SCAN・スケルチ・BUSY |
| 操作 | 上面 TUNE（ロータリーエンコーダ、押す・長押し）、VOL、POWER、MIC（PTT 付き）、EXT SP |
| 記憶 | 周波数・ステップ・スケルチを XIAO のフラッシュに保存 |

### 電源・外形

| 項目 | 値 |
|---|---|
| 電源 | DC 13.8V（送信時 約 2.5A、受信時 約 0.3A の目安）。ヒューズ 5A、逆接続は 1N5408（1N5822）でヒューズを切る |
| 基板 | 170 × 150mm、4 層（内層 2 枚は GND）、部品 328 点（表面実装は NJM2594V の 1 点だけ）、Ver 1.2 |
| ケース | 200 × 175 × 50mm（3D 印刷、OpenSCAD）。終段の放熱器のフィンを後面の窓から外に出す |

## 送信部

### セラゾイド変調

| ブロック | 部品 | 内容 |
|---|---|---|
| 基準 | Si5351 CLK0 1.83125MHz → 74HCT123（2 回路目） | CLK0 の立ち上がりで約 50〜100ns 幅のリセットパルス |
| のこぎり波 | 2SA1015 定電流源（約 300µA）＋ 68pF（C0G）、2N7000 で放電 | 傾き約 3.4V/µs（山 約 1.7V）。直線性がそのまま変調の直線性になる |
| 比較 | 2SA1015 × 2 の差動対（電流 約 2.3mA、負荷 1kΩ） | 片方にのこぎり波、もう片方にしきい値（中心は半固定 VR で調整 ± 音声）。遅れは一定なので位相のずれにならない |
| パルス整形 | 74HCT123（1 回路目。Si5351 の 3.3V を受けるため HCT 品） | 比較出力の立ち下がりでトリガ、約 273ns（デューティ 50%）に調整 |
| 音声 | MCP6004：マイクアンプ → 利得段 → IDC（±0.6V クリップ）→ 3kHz LPF → しきい値バッファ | 偏移は半固定 VR で ±5kHz に合わせる |

チャンネル変更は CLK0 を変えるだけ（出力 10kHz ステップ = CLK0 625Hz ステップ。29.000〜29.700MHz は CLK0 1.8125〜1.85625MHz）。PLL は ×16 の出力に追従する。

### 逓倍 ×16・段間同調・PLL

| 段 | 出力 | 部品 |
|---|---|---|
| ×2 段 1〜4 | 1.83 → 3.66 → 7.33 → 14.65 → 29.30MHz | 74AC86、遅延の整形 74AC14 |
| 段間同調 1〜3 | 3.66 / 7.33 / 14.65MHz を正弦波にして矩形に戻す | 1k（段 3 は 470Ω）＋ LC 並列共振（10µH・180p / 4.7µH・100p / 1µH・120p、Q 約 5、調整なし）→ 74HCU04（自己バイアス）→ 74AC14 |
| PLL | 29.30MHz の VCO を ×16 の出力に位相同期 | 74AC74（位相周波数比較）・74AC00・MCP6002（ループフィルタ）・VCO 専用の 74HCU04 の LC 発振（1N4007 を可変容量に） |

各段は XOR（x, RC で遅らせて 74AC14 で整形した x）。遅延（RC ＋ 74AC14）は入力周期の 1/4（137 → 68 → 34 → 17ns）で、出力のデューティが 50% になる。RC のなまった波形を直接 74AC86 に入れないよう、シュミットの 74AC14 を通す。

**スプリアス対策（2026-10-29、Ver 1.2）**: XOR 逓倍は、各段の遅延が 1/4 周期からずれる（74AC14 のしきい値・部品のばらつきで数 ns）と、デューティがくずれて基準周波数（F0）おきの側帯波が出る。Ver 1.1（915.625kHz × 32、段間に同調なし）は計算でアンテナ端 −13dBc 程度、ばらつき込みでは搬送波並みになり、規格（30MHz 以下: 50mW 以下かつ −50dBc）を満たさなかった。2 段の複同調 BPF も 2pF 結合で過結合になっていて、±0.92MHz では数 dB しか落ちない。そこで次の 3 つを入れた。

1. **逓倍数を減らす**: 変調を 1.83125MHz（Si5351 の CLK0 から直接）で行い ×16 に。側帯波の間隔が 1.83MHz に広がり、BPF・PLL で落としやすくなる
2. **段間同調**: 段 1〜3 の出力を LC で正弦波にし、平均値を境に矩形へ戻す（自己バイアスの 74HCU04）。前の段のデューティのくずれが約 16dB 下がり、×16 の出力でエッジが欠ける（計算では同調なしで 200 台中 160 台）ことがなくなる
3. **PLL 追従フィルタ**: ×16 の出力に 29.3MHz の VCO を位相同期させ、VCO の出力を送信する。ループ帯域は約 37kHz で、音声の位相変調（〜3kHz）はそのまま通り、±1.83MHz の側帯波は約 −77dB になる

あわせて送信 BPF の結合を 2pF → 1pF（29.0〜29.7MHz の偏差 0.6dB 以内）にした。計算（部品のばらつき 200 通り）では、アンテナ端の側帯波は最悪 −99dBc。実機ではスペクトラムアナライザで確認すること。

偏移: PM なので変調周波数に比例する。3kHz で ±5kHz のとき、変調部での位相は ±0.104rad（エッジで ±9ns、しきい値で ±31mV 程度）。変調部の電源は DC-DC ではなくリニアレギュレータ（L7805、+5VT）にして、リプルが位相雑音にならないようにしている。

受信中は VCO の入力を 2SC1815 で GND に落として発振を止める（受信周波数に VCO が漏れないように）。VCO の中心は TC（30p）で合わせる: 29.300MHz で送信し、TP「VT」が約 2.5V になるように回す。

### 電力増幅（13.8V）

| 段 | 部品 | 出力 |
|---|---|---|
| バッファ | 2N2222A（TO-92、TX8V・約 33mA） | 約 30mW |
| ドライバ | IRF510（放熱器 HS1、絶縁して取り付け） | 約 0.5W |
| ファイナル | IRF510 × 2 プッシュプル（ケースの放熱器、絶縁して取り付け） | 約 5W |

出力は BN43-202 の 1:6.25 トランス（一次 2 回・二次 5 回、ドレイン負荷 約 8Ω）→ 7 次チェビシェフ LPF（fc 約 32MHz）→ 出力検出（容量分割 ＋ 1N60、XIAO の A1 へ）。

## 受信部

| ブロック | 部品 |
|---|---|
| RF | 29MHz 複同調 BPF（T-30-6 タップ付き）→ 2N3819（ソース接地、ドレインはチョーク給電） |
| 第 1 混合 | NJM2594V（DBM、表面実装 SSOP8。局発 Si5351 CLK1）→ 10.7MHz 増幅（2SC1815、変換利得 0dB を補う） |
| 第 1 IF | 10.7MHz 水晶フィルタ（10M15A 相当） |
| 第 2 IF・検波 | MC3361（10.245MHz 水晶、455kHz セラミックフィルタ、CDBM455 ディスクリミネータ） |
| スケルチ | ノイズ（7kHz 以上）を MCP6002 で増幅・検波して XIAO の A2 へ。XIAO が LM386 入力をミュート |
| S メーター | 10.7MHz 水晶フィルタの出力を 2.2kΩ で取り出し → 2SC1815 同調増幅（4.7µH・47p、約 26dB）→ AD8307（対数増幅、25mV/dB、DIP-8）→ ADS1115 モジュール（I2C、A0）→ XIAO。計算で S2〜S9＋40 程度（MC3361 に RSSI 出力がないため、2026-10-29 に追加） |
| AF | LM386（約 0.5W） |

## 制御部

- XIAO ESP32C3：ロータリーエンコーダでチャンネル選択、PTT、送受切替リレー、スケルチ、周波数スキャン、表示器（Nextion NX4832T035、PSN_TRX と同じ。TJC4832T135 も可。アナログ S メーター・送信出力計）。スケッチは [firmware/Serrasoid_TRX](firmware/Serrasoid_TRX/)
- 送受切替は G5V-2 1 個: 1 極目でアンテナ、2 極目で 8V を RX8V / TX8V に振り分ける（送信系のバイアスは TX8V のときだけかかる）

| XIAO | 用途 | XIAO | 用途 |
|---|---|---|---|
| D0 | PTT 入力（起動設定ピン） | D6 | 表示器 TX |
| D1/A1 | 出力検出 | D7 | ミュート出力 |
| D2/A2 | スケルチ用ノイズ | D8 | エンコーダ B |
| D3 | エンコーダ A | D9 | エンコーダ SW（起動設定ピン） |
| D4/D5 | I2C（Si5351・ADS1115） | D10 | 送信（リレー）出力 |

ESP32-C3 は電源投入時に GPIO2（D0）と GPIO9（D9）が High のときフラッシュから起動するので、この 2 本にはふだん開放の PTT とエンコーダ SW をつないでいる。PTT やつまみを押したまま電源を入れないこと。
- 送信時は CLK0（変調基準 = 送信周波数 ÷ 16）、受信時は CLK1（局発）。受信中は CLK0 を止めて自局の回り込みを防ぐ（VCO は受信中 RX8V で止まる）

## 電源

| 電源 | 作り方 | 主な使い先 |
|---|---|---|
| +13V8 | DC 入力（逆接続は 1N5408 でヒューズを切る） | IRF510 のドレイン、リレー |
| +5V | R-78E5.0-1.0（DC-DC） | XIAO・表示器 |
| +8V | L7808 | リレー 2 極目経由で RX8V / TX8V |
| +5VT | L7805（+8V から） | セラゾイド変調・逓倍・送信音声 |
| +5VA | 78L05（RX8V から） | NJM2594・MC3361・スケルチ |
| +3V3S | LP2950-3.3 | Si5351 モジュール |

論理チェックの結果は [docs/回路図論理チェック.md](docs/回路図論理チェック.md)。

## 再生成のしかた

```
python3 tools/mklib.py     # 記号・フットプリントのライブラリ
python3 tools/gen_sch.py   # 回路図（部品配置と結線を自動で行う）
python3 tools/gen_bom.py   # 部品表
# 基板（KiCad 付属の Python で配置、Freerouting 1.9.0 で配線。jar は ~/tools/freerouting-1.9.jar、別の場所なら FREEROUTING= で指定）
/Applications/KiCad/KiCad.app/Contents/Frameworks/Python.framework/Versions/Current/bin/python3 tools/gen_pcb.py
tools/route.sh
tools/check.sh             # 回路図を作り直して ERC と接続照合（tools/verify_sch.py）
```

回路図での部品の位置は `tools/circuit.py` の `LAYOUT` で手で決めてある（ない部品は自動で置く）。KiCad で部品を動かしたときは `python3 tools/import_layout.py` で位置を `LAYOUT` に取り込める。回路を直すときは `tools/circuit.py` を編集して作り直す（KiCad で回路図を直接直した場合は、circuit.py にも同じ修正を入れる）。

## 運用上の注意

- 29MHz 帯 FM は 4 級でも 10W まで運用可（この機械は約 5W）。自作機のため保証認定（JARD / TSS）と変更申請が必要
- 逓倍方式は分数調波・隣の逓倍成分が出やすい。PLL 追従フィルタで落としているが、スペクトラムアナライザでスプリアスが規格内か確認すること（特に ±1.83MHz（27.47・31.13MHz）、14.65MHz・43.95MHz 付近）。PLL が外れる（TP「VT」が 0V か 5V に張り付く）と VCO が勝手な周波数で出るので、送信前に VT を確認する
- 周波数は JARL バンドプランの FM 区分に合わせる

## 組み立て方

### 1. 部品をそろえる

- [購入用部品表](kicad/bom_purchase.csv)（Excel で開ける）に、部品ごとの購入先・型番・販売コード・入数・価格を載せています。大半は秋月電子、秋月にないものは DigiKey など（2026-10-29 に在庫を調べた結果をメモ欄に記載）。
- **入手に注意する部品**（早めに確保するか、代わりを検討）: MC3361（Motorola 品は製造中止、UTC の互換品あり）、CDBM455C24（製造中止の恐れ）、AD8307ANZ（DigiKey の標準納期 10 週）、2N3819（取り寄せ）。74HCT4017・MAX913・2N3866・RD06HHF1・RD16HHF1 は 2026-10-29 に手に入りやすい部品（74HCT123 の 2 回路目・2SA1015 の差動対・2N2222A・IRF510）に置き換えました。
- 基板の外の部品（IC ソケット、パネルのコネクタ、LCD、ねじなど）も購入用部品表の最後にまとめてあります。

### 2. 基板を作る

- 基板データは `kicad/Serrasoid_TRX.kicad_pcb`（KiCad 10、170 × 150mm、4 層）。
- **製造データ**: [kicad/production/Serrasoid_TRX_Gerber_JLCPCB.zip](kicad/production/Serrasoid_TRX_Gerber_JLCPCB.zip)（ガーバー 11 層＋ドリル＋ジョブファイル）をそのまま基板メーカーにアップロードします。発注のときの指定（4 層・1.6mm・最小穴 0.4mm など）は [kicad/production/JLCPCB_提出資料.md](kicad/production/JLCPCB_提出資料.md)。部品の実装は頼まず、手はんだで組み立てます。

### 3. はんだ付け

[部品実装図（PDF、9 ページ）](docs/Serrasoid_TRX_部品実装図.pdf)の 2 ページ目から、ブロックごとに部品と注意（極性・NP0 など）が載っています。A3 1 枚の配置図は [kicad/Serrasoid_TRX_部品配置図.pdf](kicad/Serrasoid_TRX_部品配置図.pdf)。

1. **U10 NJM2594V（表面実装 SSOP8、0.65mm ピッチ）を最初に**付ける。細いこて先とフラックスで、周りの部品より先に。
2. **電源**: J1・D1・U4（L7808、小型放熱器）・U6（L7805）・U5（R-78E）・U8（LP2950）と周りのコンデンサ。13.8V を入れて +8V・+5V・+5VT・+3V3S を確かめてから次へ。
3. **制御**: XIAO（U15）はピンソケット、Si5351 モジュール（U11）はピンヘッダ、ADS1115 モジュール（U13）はピンソケットに差す。リレー K1、エンコーダ・LCD などのコネクタ。
4. **セラゾイド変調 → 逓倍 → PLL → 送信音声**: IC はすべてソケット。74AC14（U20・U23）・74AC86（U21）・74AC74（U1）・74AC00（U3）は**必ず AC 品**、74HCU04（U22・U12）は**必ず U 付き**。遅延・同調・のこぎり波のコンデンサは NP0（C0G）。
5. **送信 RF**: ドライバ Q12 IRF510 は放熱器 HS1 に、ファイナル Q14・Q13 IRF510 は基板の後ろの端に立ててケースの放熱器にねじ止め。**IRF510 はタブ = ドレイン（+13.8V）なので、3 個とも絶縁シートと絶縁ブッシングで放熱器から絶縁**し、テスターで放熱器とドレインが導通していないことを確かめる。LPF のコンデンサは NP0 500V 以上。
6. **受信**: 水晶フィルタ FL1・セラミックフィルタ FL2 は中央の足が GND。S メーターの U9 AD8307 はソケット。

**コイルの巻き方**

| 部品 | コア | 巻き方 |
|---|---|---|
| L1・L4（受信 BPF）、L7・L8（送信 BPF） | T-30-6 | 0.4mm 線 17 回、コールド側から 2 回目でタップ（L4 はタップを使わない） |
| L13・L16 / L15（送信 LPF） | T-50-6 | 0.8mm 線 9 回 / 10 回 |
| L6（VCO） | T-50-6 | 0.5mm 線 15 回（約 0.9µH） |
| L10（ドライバのチョーク） | FT-37-43 | 10 回 |
| T1（入力トランス） | BN-43-202 | 0.4mm 線、一次 2 回・二次 2 回（二次はセンタータップを出す） |
| T2（出力トランス） | BN-43-202 | 一次 0.8mm 線 2 回（センタータップを出す）・二次 3 回 |

### 4. スケッチを書き込む

1. Arduino IDE（または arduino-cli）に ESP32 のボード（esp32 by Espressif）と、ライブラリ **Etherkit Si5351** を入れる。
2. ボードは **XIAO_ESP32C3**。`firmware/Serrasoid_TRX/Serrasoid_TRX.ino` を開いて書き込む。
3. 書き込み時、PTT とつまみは押さないこと（D0・D9 は起動設定ピン）。

### 5. LCD の画面データを作る

[firmware/Serrasoid_TRX/nextion/画面データ作成手順.md](firmware/Serrasoid_TRX/nextion/画面データ作成手順.md) のとおり、Nextion Editor（TJC は USART HMI、どちらも Windows）で背景画像とテキスト部品 7 個の画面を作り、microSD で LCD に書き込みます。基板の J3 の 2 番を LCD の RX（黄）につなぎます。

### 6. 調整

オシロスコープ・テスター・周波数カウンタ（またはスペクトラムアナライザ）・ダミーロード（50Ω 10W 以上）・FM 受信機を使います。**送信は必ずダミーロードで**。

| 順 | 調整 | 方法 |
|---|---|---|
| 1 | 電源電圧 | +13V8・+8V・+5V・+5VT・+5VA（受信中）・+3V3S |
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
## KiCad design kicad/Serrasoid_TRX.kicad_pcb

Schematic: Serrasoid_TRX.kicad_sch, Serrasoid TRX 29M（セラゾイド変調 29MHz FM 5W トランシーバ）

Parts:
C1, C3, C6, C10, C16, C17, C18, C19, C24, C34, C37, C38, C39, C40, C41, C42, C45, C46, C49, C50, C56, C61, C63, C65, C81, C85, C86, C97, C99, C101, C106, C107, C109, C113, C124: 0.1u; C_Disc_D5.0mm_W2.5mm_P2.50mm
C2: 470u; CP_Radial_D8.0mm_P3.50mm
C4, C11, C84, C87, C89: 22p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C5: 0.33u; C_Disc_D5.0mm_W2.5mm_P2.50mm
C7, C12, C15, C21, C28, C35, C58, C66, C74, C82: 10u; CP_Radial_D5.0mm_P2.00mm
C8, C20, C22, C25, C26, C27, C29, C30, C31, C32, C33, C43, C47, C53, C54, C62, C90, C93, C94, C95, C96, C98, C100, C108, C110, C123: 0.01u; C_Disc_D5.0mm_W2.5mm_P2.50mm
C9: 2p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C13, C14, C52, C75: 220p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C23, C44, C112: 47p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C36: 470p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C48: 27p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C51, C79: 68p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C55: 56p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C57, C77: 2.2n; C_Disc_D5.0mm_W2.5mm_P2.50mm
C59, C67: 0.047u; C_Disc_D5.0mm_W2.5mm_P2.50mm
C60, C71, C76, C80: 1u; C_Disc_D5.0mm_W2.5mm_P2.50mm
C64: 100u; CP_Radial_D6.3mm_P2.50mm
C68: 0.47u; C_Disc_D5.0mm_W2.5mm_P2.50mm
C69: 220u; CP_Radial_D6.3mm_P2.50mm
C70, C72, C73: 47u; CP_Radial_D5.0mm_P2.00mm
C78: 4.7n; C_Disc_D5.0mm_W2.5mm_P2.50mm
C83, C91, C111, C117, C122: 100p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C88: 1p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C92: 82p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C102: 180p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C103: 120p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C104, C105, C119: 1000p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C114: 220u; CP_Radial_D8.0mm_P3.50mm
C115, C120: 120p; C_Disc_D5.0mm_W2.5mm_P5.00mm
C116, C118: 220p; C_Disc_D5.0mm_W2.5mm_P5.00mm
C121: 4.7p; C_Disc_D3.0mm_W1.6mm_P2.50mm
D1: 1N5408; D_DO-201AD_P5.08mm_Vertical_AnodeUp
D2, D3, D9, D10, D11, D12: 1N4148; D_DO-35_SOD27_P2.54mm_Vertical_AnodeUp
D4: 1N4007; D_DO-41_SOD81_P5.08mm_Vertical_AnodeUp
D5: 1N5819; D_DO-41_SOD81_P5.08mm_Vertical_AnodeUp
D6, D7, D13: 1N60; D_DO-35_SOD27_P2.54mm_Vertical_AnodeUp
D8: 1N4001; D_DO-41_SOD81_P5.08mm_Vertical_AnodeUp
FL1: 10M15A; Crystal_HC49-U-3Pin_Vertical
FL2: CFWLA455KFFA; Filter_Ceramic_3pin_P2.54mm
J1: DC 13.8V; SolderWire-1sqmm_1x02_P5.4mm_D1.4mm_OD2.7mm
J2: I2C; PinHeader_1x04_P2.54mm_Vertical
J3: LCD; PinHeader_1x04_P2.54mm_Vertical
J4: VOL; PinHeader_1x03_P2.54mm_Vertical
J5: ENC; PinHeader_1x05_P2.54mm_Vertical
J6: SP; PinHeader_1x02_P2.54mm_Vertical
J7: MIC; PinHeader_1x03_P2.54mm_Vertical
J8: ANT; SolderWire-1sqmm_1x02_P5.4mm_D1.4mm_OD2.7mm
J9: TX LED; PinHeader_1x02_P2.54mm_Vertical
K1: G5V-2 DC12; Relay_DPDT_Omron_G5V-2
L1, L4, L7, L8: T30-6 17T/2T; L_T30_3pin_Vertical
L2, L5, L9, L11: 10uH; L_Axial_L9.5mm_D4.0mm_P2.54mm_Vertical_Fastron_SMCC
L3, L14: 4.7uH; L_Axial_L9.5mm_D4.0mm_P2.54mm_Vertical_Fastron_SMCC
L6: T50-6 15T; L_T50_2pin_Vertical
L10: FT37-43 10T; L_T50_2pin_Vertical
L12: 1uH; L_Axial_L9.5mm_D4.0mm_P2.54mm_Vertical_Fastron_SMCC
L13, L16: T50-6 9T; L_T50_2pin_Vertical
L15: T50-6 10T; L_T50_2pin_Vertical
Q1, Q3, Q4, Q5, Q6: 2SC1815; TO-92_Inline
Q2: 2N3819; TO-92_Inline
Q7: 2N7000; TO-92_Inline
Q8, Q9, Q10: 2SA1015; TO-92_Inline
Q11: 2N2222A; TO-92_Inline
Q12, Q13, Q14: IRF510; TO-220-3_Vertical
R1, R56, R65, R76: 2.2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R2, R3, R8, R9: 5.6k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R4, R19, R21, R54: 22k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R5, R10, R22, R32, R34, R41: 4.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R6: 27; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R7, R36: 220; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R11, R15, R23, R59, R69, R74, R75: 1.5k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R12, R43, R44, R45, R98: 330; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R13: 1.2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R14, R18, R20, R27, R50, R73, R85, R87, R89, R99: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R16, R64, R68: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R17, R49, R84, R95, R96: 10; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R24: 82; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R25: 180; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R26, R28, R29, R33, R35, R37, R38, R39, R40, R42, R47, R48, R52, R53, R57, R58, R60, R62, R70, R72, R101, R103: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R30, R90, R91, R100: 1M; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R31: 20k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R46: 470k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R51, R63, R71: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R55, R88: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R61: 220k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R66, R67: 15k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R77: 120; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R78: 1.8k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R79: 510; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R80: 560; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R81: 4.7; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R82: 18; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R83: 47; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R86, R92: 3.3k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R93, R94: 22; R_Axial_DIN0414_L11.9mm_D4.5mm_P5.08mm_Vertical
R97: 910; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R102: 47k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
T1: BN43-202 2T:2T(CT); Transformer_BN43-202_SS
T2: BN43-202 2T(CT):3T; Transformer_BN43-202_SP
TC1, TC2, TC3, TC4, TC5: 30p; C_Trimmer_TMCV01
TP1: VT; TestPoint_THTPad_D1.5mm_Drill0.7mm
TP2: TXOSC; TestPoint_THTPad_D1.5mm_Drill0.7mm
TP3: RAMP; TestPoint_THTPad_D1.5mm_Drill0.7mm
TP4: THRESH; TestPoint_THTPad_D1.5mm_Drill0.7mm
TP5: COMP; TestPoint_THTPad_D1.5mm_Drill0.7mm
TP6: PM; TestPoint_THTPad_D1.5mm_Drill0.7mm
TP7: X16; TestPoint_THTPad_D1.5mm_Drill0.7mm
U1: 74AC74; DIP-14_W7.62mm_Socket
U2: 78L05; TO-92_Inline
U3: 74AC00; DIP-14_W7.62mm_Socket
U4: L7808; TO-220-3_Vertical
U5: R-78E5.0-1.0; Converter_DCDC_RECOM_R-78E-0.5_THT
U6: L7805; TO-220-3_Vertical
U7, U16: MCP6002; DIP-8_W7.62mm_Socket
U8: LP2950-3.3; TO-92_Inline
U9: AD8307ANZ; DIP-8_W7.62mm_Socket
U10: NJM2594V; TSSOP-8_4.4x3mm_P0.65mm
U11: AE-Si5351A; DIP-8_W7.62mm
U12, U22: 74HCU04; DIP-14_W7.62mm_Socket
U13: ADS1115 module; ADS1115_Module_Socket
U14: MC3361; DIP-16_W7.62mm_Socket
U15: XIAO ESP32C3; Seeeduino_XIAO_Socket
U17: LM386N-1; DIP-8_W7.62mm_Socket
U18: MCP6004; DIP-14_W7.62mm_Socket
U19: 74HCT123; DIP-16_W7.62mm_Socket
U20, U23: 74AC14; DIP-14_W7.62mm_Socket
U21: 74AC86; DIP-14_W7.62mm_Socket
VR1, VR3, VR4: 10k; Potentiometer_TOCOS_GF063P_Vertical
VR2: 1k; Potentiometer_TOCOS_GF063P_Vertical
VR5, VR6, VR7: 5k; Potentiometer_TOCOS_GF063P_Vertical
X1: 10.245MHz; Crystal_HC49-U_Vertical
X2: CDBM455C24; C_Disc_D5.0mm_W2.5mm_P5.00mm

Connections:
+3V3S: C35.1, C37.1, U8.1 (VO), U11.1 (VDDO), U11.8 (VDD)
+3V3X: J2.1, R29.1, R32.1, R34.1, R35.1, R47.1, R48.1, U13.1 (VDD), U15.10 (3V3)
+5V: C21.1, C24.1, D5.2 (A), J3.1, U5.3 (OUT), U8.3 (VI)
+5VA: C7.1, C41.1, C49.2, C50.2, C52.2, C56.1, C65.1, R17.1, R31.2, R38.1, U2.1 (VO), U10.1 (V+), U14.4 (VCC), U16.8 (V+), X1.2, X2.2
+5VT: C1.1, C10.1, C16.1, C28.1, C34.1, C39.1, C81.1, C85.1, C86.1, C97.1, C101.1, C107.1, C113.1, D11.2 (A), R55.1, R57.1, R69.1, R74.1, R75.1, R76.1, U1.2 (D), U1.4 (~S), U1.10 (~S), U1.12 (D), U1.14 (VCC), U3.14 (VCC), U6.3 (OUT), U7.8 (V+), U12.14 (VCC), U18.4 (V+), U19.2 (B), U19.3 (Clr), U19.11 (Clr), U19.16 (VCC), U20.14 (VCC), U21.14 (VCC), U22.14 (VCC), U23.14 (VCC), VR4.1
+8V: C15.1, C17.1, C19.1, K1.13, U4.3 (OUT), U6.1 (IN)
+13V8: C2.1, C5.1, C6.1, C99.1, C109.1, C110.1, C114.1, D1.1 (K), D8.1 (K), J1.1, K1.1, L2.1, L10.1, T2.2 (PM), U4.1 (IN)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C27.2, C28.2, C29.2, C30.2, C31.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C45.2, C46.2, C48.2, C53.2, C55.2, C56.2, C58.2, C59.2, C61.2, C64.2, C65.2, C66.2, C67.2, C68.2, C70.2, C72.2, C73.2, C74.2, C79.2, C82.2, C85.2, C86.2, C87.2, C89.2, C91.2, C92.2, C93.2, C94.2, C96.2, C97.2, C98.2, C99.2, C101.2, C102.2, C103.2, C106.2, C107.2, C108.2, C109.2, C110.2, C111.2, C112.2, C113.2, C114.2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; also elsewhere on the board
unnamed: C4.1, C9.1, L1.1, TC1.1
unnamed: C8.1, R1.2
unnamed: C13.1, R2.2, R8.1
unnamed: C14.1, R3.2, R9.1
unnamed: C18.1, R6.2, R7.1
unnamed: C20.1, R11.2
unnamed: C25.1, R15.2
unnamed: C33.1, R13.2, R16.1
unnamed: C36.1, R18.2, R19.1, TP1.1
unnamed: C46.1, R24.2, R25.1
unnamed: C54.1, C55.1, R36.2
unnamed: C54.2, L6.1
unnamed: C57.2, R39.1
unnamed: C59.1, C60.1, R37.2
unnamed: C62.1, R43.2, R44.2, R45.2
unnamed: C63.1, R46.2, U16.1
unnamed: C67.1, R49.2
unnamed: C69.1, R49.1, U17.5
unnamed: C70.1, R55.2, R56.1
unnamed: C71.2, R60.1
unnamed: C75.2, C76.1, R61.2, U18.1
unnamed: C76.2, VR1.1
unnamed: C78.1, R66.2, R67.1
unnamed: C80.2, VR3.1
unnamed: C82.1, R72.1, VR4.2
unnamed: C87.1, C88.1, L7.1, TC4.1
unnamed: C88.2, C89.1, L8.1, TC5.1
unnamed: C91.1, R78.2, U20.1
unnamed: C92.1, R79.2, U20.5
unnamed: C93.1, R81.2, R82.1
unnamed: C95.2, R83.1, R84.1, R85.2
unnamed: C96.1, R83.2
unnamed: C98.1, R85.1, VR6.2
unnamed: C102.1, C104.1, L11.1, R87.2
unnamed: C103.1, C105.1, L12.1, R88.2
unnamed: C104.2, R90.1, U22.1
unnamed: C105.2, R91.1, U22.5
unnamed: C108.1, R89.1, VR7.2
unnamed: C111.1, R97.2, U20.3
unnamed: C112.1, R98.2, U20.9
unnamed: C116.1, L13.2, L15.1
unnamed: C117.1, C119.1, L14.1, R99.2
unnamed: C118.1, L15.2, L16.1
unnamed: C119.2, R100.1, U22.3
unnamed: C120.1, C121.1, K1.8, L16.2
unnamed: D2.2 (A), D3.1 (K), K1.6, L1.2 (TAP)
unnamed: C44.2, D4.1 (K), R19.2
unnamed: D5.1 (K), U15.8 (VIN)
unnamed: C63.2, D6.1 (K), D7.2 (A)
unnamed: C68.1, D7.1 (K), R51.1, R53.1
unnamed: D8.2 (A), K1.16, Q6.2 (C)
unnamed: C74.1, C77.2, D9.1 (K), D10.2 (A), R57.2, R58.1, R62.2, U18.3 (+), VR1.3, VR3.3
unnamed: D9.2 (A), D10.1 (K), R65.2, R66.1
unnamed: D11.1 (K), D12.2 (A)
unnamed: C81.2, D12.1 (K), Q8.3 (B), R70.1
unnamed: C121.2, C122.1, D13.2 (A), R101.1
unnamed: C123.1, D13.1 (K), R102.1, R103.1
unnamed: C47.2, FL1.1 (IN)
unnamed: FL1.3 (OUT), R1.1, U14.16 (MIX_IN)
unnamed: FL2.1 (IN), U14.3 (MIX_OUT)
unnamed: FL2.3 (OUT), U14.5 (LIM_IN)
unnamed: J2.2, R34.2, U11.2 (SCL), U13.3 (SCL), U15.6 (D5/SCL)
unnamed: J2.3, R32.2, U11.3 (SDA), U13.4 (SDA), U15.5 (D4/SDA)
unnamed: J3.2, U15.7 (D6/TX)
unnamed: C60.2, J4.1
unnamed: J4.2, R41.1
unnamed: J5.1, R29.2, U15.4 (D3/A3)
unnamed: J5.2, R47.2, U15.13 (D8/SCK)
unnamed: J5.3, R48.2, U15.12 (D9/MISO)
unnamed: C69.2, J6.1
unnamed: C71.1, J7.1, R56.2
unnamed: J7.2, R27.1
unnamed: J8.1, K1.4
unnamed: J9.1, R59.2
unnamed: C62.2, L7.2 (TAP)
unnamed: C90.1, L8.2 (TAP)
unnamed: C8.2, Q1.3 (B), R4.2, R5.1
unnamed: C23.1, C26.1, L3.2, Q1.2 (C)
unnamed: Q1.1 (E), R6.1
unnamed: C32.1, L5.2, Q2.1 (D), R14.2
unnamed: C9.2, C11.1, L4.1, Q2.2 (G), R10.1, TC2.1
unnamed: C29.1, Q2.3 (S), R12.1
unnamed: C43.2, Q3.3 (B), R21.2, R22.1
unnamed: C47.1, Q3.2 (C), R23.2
unnamed: Q3.1 (E), R24.1
unnamed: Q4.3 (B), R26.2, R28.1
unnamed: C44.1, C48.1, L6.2, Q4.2 (C), R30.1, TC3.1, U12.1
unnamed: Q5.3 (B), R40.2, R42.1
unnamed: Q5.2 (C), R41.2, U17.3 (+)
unnamed: Q6.3 (B), R50.2, R52.1
unnamed: C79.1, Q7.3 (D), Q8.2 (C), Q9.3 (B), TP3.1
unnamed: Q7.2 (G), R68.2
unnamed: Q8.1 (E), VR2.2, VR2.3
unnamed: Q9.2 (C), R73.1, TP5.1, U19.1 (A)
unnamed: Q10.3 (B), TP4.1, U18.13 (-), U18.14
unnamed: Q9.1 (E), Q10.1 (E), R74.2
unnamed: C90.2, Q11.2 (B), R77.1, R80.2
unnamed: C95.1, L9.2, Q11.3 (C)
unnamed: Q11.1 (E), R81.1
unnamed: C100.1, L10.2, Q12.2 (D)
unnamed: Q12.1 (G), R84.2
unnamed: Q13.2 (D), T2.1 (PR1)
unnamed: Q13.1 (G), R95.2
unnamed: Q14.2 (D), T2.3 (PR2)
unnamed: Q14.1 (G), R96.2
unnamed: R15.1, R18.1, U7.1
unnamed: R30.2, R36.1, U12.2, U12.3, U12.5, U12.9, U12.11
unnamed: R43.1, TP2.1, U12.6
unnamed: R44.1, U12.8
unnamed: R45.1, U12.10
unnamed: R63.2, R65.1, U18.7
unnamed: R69.2, VR2.1
unnamed: R71.1, VR3.2
unnamed: R76.2, VR5.1
unnamed: R79.1, U20.12, U21.9
unnamed: R86.2, VR6.1
unnamed: R87.1, U21.3
unnamed: R88.1, U21.8
unnamed: R90.2, U20.11, U22.2
unnamed: R91.2, U22.6, U23.1
unnamed: R92.2, VR7.1
unnamed: R97.1, U20.10, U21.4
unnamed: R98.1, U21.12, U23.2
unnamed: R99.1, U21.6
unnamed: R100.2, U20.13, U22.4
unnamed: C100.2, T1.1 (AA)
unnamed: R94.1, R96.1, T1.3 (SA)
unnamed: R93.1, R95.1, T1.5 (SB)
unnamed: C106.1, R89.2, R93.2, R94.2, T1.4 (SC)
unnamed: C115.1, L13.1, T2.4 (S1)
unnamed: TP7.1, U1.3 (C), U21.11
unnamed: R2.1, U1.5 (Q), U3.1
unnamed: U1.1 (~R), U1.13 (~R), U3.3
unnamed: U1.11 (C), U12.4
unnamed: R3.1, U1.9 (Q), U3.2
unnamed: C12.1, L2.2, U5.1 (IN)
unnamed: R8.2, R11.1, U7.3 (+)
unnamed: C25.2, R9.2, U7.2 (-)
unnamed: U7.6 (-), U7.7
unnamed: C38.1, R17.2, U9.6 (ENB), U9.7 (VPS)
unnamed: C27.1, U9.1 (INM)
unnamed: C26.2, U9.8 (INP)
unnamed: C30.1, U9.3 (OFS)
unnamed: C42.1, U10.6 (BYP)
unnamed: C33.2, U10.7 (CARR)
unnamed: C43.1, R20.1, U10.3 (OUT2)
unnamed: C32.2, U10.5 (SIG)
unnamed: R64.1, U11.5 (CLK0)
unnamed: R13.1, U11.6 (CLK1)
unnamed: C40.1, U9.4 (OUT), U13.7 (A0)
unnamed: C57.1, R37.1, U14.9 (AUDIO)
unnamed: C49.1, U14.6 (DEC1)
unnamed: C50.1, U14.7 (DEC2)
unnamed: C51.1, U14.1 (OSC_B), X1.1
unnamed: C51.2, C52.1, U14.2 (OSC_E)
unnamed: R31.1, U14.8 (QUAD), X2.1
unnamed: C53.1, R27.2, R35.2, U15.1 (D0/A0)
unnamed: C124.1, R103.2, U15.2 (D1/A1)
unnamed: R53.2, R54.1, U15.3 (D2/A2)
unnamed: R40.1, U15.14 (D7/RX)
unnamed: R50.1, U15.11 (D10/MOSI)
unnamed: C58.1, R33.1, R38.2, U16.3 (+), U16.5 (+)
unnamed: R39.2, R46.1, U16.2 (-)
unnamed: U16.6 (-), U16.7
unnamed: C66.1, U17.7 (BYPASS)
unnamed: C75.1, R60.2, R61.1, U18.2 (-)
unnamed: U18.5 (+), VR1.2
unnamed: R62.1, R63.1, U18.6 (-)
unnamed: C77.1, R67.2, U18.10 (+)
unnamed: C78.2, C80.1, U18.8, U18.9 (-)
unnamed: R71.2, R72.2, U18.12 (+)
unnamed: C83.1, U19.14 (Cext)
unnamed: R78.1, TP6.1, U19.13 (Q), U21.1
unnamed: C83.2, U19.15 (RCext), VR5.2, VR5.3
unnamed: R64.2, U19.10 (B)
unnamed: C84.1, U19.6 (Cext)
unnamed: R68.1, U19.5 (Q)
unnamed: U20.2, U21.2
unnamed: U20.4, U21.5
unnamed: U20.6, U21.10
unnamed: U20.8, U21.13
OS2_RC: C84.2, R75.2, U19.7 (RCext)
RX8V: C3.1, C22.1, C31.1, C45.1, C61.1, C64.1, C72.1, K1.11, L3.1, L5.1, R4.1, R14.1, R21.1, R23.1, R26.1, U2.3 (VI), U17.6 (V+)
TX8V: C73.1, C94.1, K1.9, L9.1, R59.1, R80.1, R86.1, R92.1

Notes on the sheet:
セラゾイド変調
PLL
送信音声
送信RF
送信: マイク → 送信音声 → セラゾイド変調（1.83125MHz で PM）→ 逓倍 ×16（段間同調）→ PLL（VCO 29.3MHz）→ 送信RF（10W）→ ANT 受信: ANT → 受信（2N3819 → NJM2594 → 10.7MHz 増幅 → 10.7MHz → MC3361 → LM386）→ SP 制御: XIAO ESP32C3 ＋ Si5351（CLK0 = 変調基準 1.83125MHz、CLK1 = 受信局発 18.6MHz） ブロックの中もブロックの間も線で結線（電源も線。電源の名前は出どころの電源記号で示す。GND だけ GND 記号）

Board: 4 copper layers, 170.0 x 150.0 mm, 333 parts (0 on the bottom side), 192 nets.

Other parts of the board:
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3_Pad
HS1: 20PB020; Heatsink_20PB020

Their connections:
GND: H1.1, H2.1, H3.1, H4.1; also elsewhere on the board

File kicad/BOM.md (part):

# Serrasoid TRX 29M 部品表（BOM）

回路一覧 `tools/circuit.py` から `tools/gen_bom.py` で生成。回路図 `Serrasoid_TRX.kicad_sch` と同じ内容。

- 部品はリード部品。第 1 混合の NJM2594V（U13）だけ表面実装（SSOP8、0.65mm ピッチ。SA612 が製造中止のため）
- IC はすべて丸ピン IC ソケットを使う前提のフットプリント
- 基板専用部品（回路図にない）: RD06HHF1 の放熱器（秋月 20PB020）、取付穴

## 抵抗 R

| Reference | 値 / 型番 | フットプリント | 数量 | 購入先 | 購入先の型番（販売コード） | 備考 |
|---|---|---|---|---|---|---|
| R1, R56, R65, R76 | 2.2k | R Axial DIN0207 L6.3mm D2.5mm P2.54mm Vertical | 4 | 秋月電子 | CF25J2K2B（125222） | R1: 取り出し。水晶フィルタの終端（MC3361 の入力）に重い負荷をかけないため<br>R56: エレクトレットのバイアス<br>R65: IDC（クリップ） |
| R2, R3, R8, R9 | 5.6k | R Axial DIN0207 L6.3mm D2.5mm P2.54mm Vertical | 4 | 秋月電子 | RD25S 5K6（125562） |  |
| R4, R19, R21, R54 | 22k | R Axial DIN0207 L6.3mm D2.5mm P2.54mm Vertical | 4 | 秋月電子 | CF25J22KB（125223） | R4: S メーター増幅のベースバイアス（約 1.4V）<br>R21: 10.7MHz 増幅のベースバイアス（約 1.4V）<br>R54: ADC 入力を 3.1V 以下に |
| R5, R10, R22, R32, R34, R41 | 4.7k | R Axial DIN0207 L6.3mm D2.5mm P2.54mm Vertical | 6 | 秋月電子 | CF25J4K7B（125472） | R10: Q 調整<br>R32, R34: I2C プルアップ |
| R6 | 27 | R Axial DIN0207 L6.3mm D2.5mm P2.54mm Vertical | 1 | 秋月電子 | CF25J27RB（114273） | エミッタ帰還（バイパスしない） |
| R7, R36 | 220 | R Axial DIN0207 L6.3mm D2.5mm P2.54mm Vertical | 2 | 秋月電子 | CF25J220RB（125221） | R36: 出力の直列抵抗（発振振幅・高調波を抑える） |
| R11, R15, R23, R59, R69, R74, R75 | 1.5k | R Axial DIN0207 L6.3mm D2.5mm P2.54mm Vertical | 7 | 秋月電子 | CF25J1K5B（125152） | R15: ダンピング（ζ 約 0.7）<br>R23: コレクタ負荷（水晶フィルタの入力側の終端。10M15A の規格に合わせて調整）<br>R59: TX ランプ電流<br>R69: 定電流源エミッタ抵抗<br>R74: 差動対の電流（約 (5 − 0.85 − 0.65) ÷ 1.5k ≒ 2.3mA）<br>R75: リセットパルス 約 50〜100ns |
| R12, R43-R45, R98 | 330 | R Axial DIN0207 L6.3mm D2.5mm P2.54mm Vertical | 5 | 秋月電子 | CF25J330RB（125331） | R43: 送信 BPF への直列抵抗。VCO の出力バッファ 3 回路を 330Ω ずつで合わせる（並列で約 110Ω）<br>R44: VCO の出力バッファ 2 個目の直列抵抗<br>R45: VCO の出力バッファ 3 個目の直列抵抗<br>R98: ×2 段 4 の遅延 17ns（14.65MHz の 1/4 周期） |
| R13 | 1.2k | R Axial DIN0207 L6.3mm D2.5mm P2.54mm Vertical | 1 | 秋月電子 | CF25J1K2B（125122） | 局発を約 106mVrms に減衰（NJM2594 のキャリア入力 1200Ω。データシートの規格 100mVrms・−7dBm、約 100mV 以上で出力一定） |
| R14, R18, R20, R27, R50, R73, R85, R87, R89, R99 | 1k | R Axial DIN0207 L6.3mm D2.5mm P2.54mm Vertical | 10 | 秋月電子 | CF25J1KB（125102） | R14: 負荷（NJM2594 の入力 600Ω と並列で約 375Ω、利得 約 4dB。感度が足りなければ外す）<br>R20: NJM2594 のエミッタフォロワの負荷（アイドル電流 約 3.3mA ＝（5V − 1.7V）÷ 1k）<br>R27: PTT 保護抵抗<br>R50: リレー駆動のベース電流 約 2.6mA（コイル約 42mA を確実に飽和させる）<br>R73: 負荷。RAMP < THRESH で約 2.3V、超えると 0V<br>R85: ゲートバイアス<br>R87: 同調 1（3.66MHz）の駆動。Q 約 5 を決める<br>R89: ゲートバイアス（入力トランスのセンタータップへ）<br>R99: 同調 2（7.33MHz）の駆動。Q 約 5 を決める |
| R16, R64, R68 | 100 | R Axial DIN0207 L6.3mm D2.5mm P2.54mm Vertical | 3 | 秋月電子 | CF25J100RB（125101） | R64: Si5351 CLK0（1.83125MHz）の直列抵抗 |
| R17, R49, R84, R95, R96 | 10 | R Axial DIN0207 L6.3mm D2.5mm P2.54mm Vertical | 5 | 秋月電子 | CF25J10RB（125100） | R17: 電源のデカップリング（データシートの応用回路）<br>R84: ゲートストッパー<br>R95: ゲートストッパー（B）<br>R96: ゲートストッパー（A） |
| R24 | 82 | R Axial DIN0207 L6.3mm D2.5mm P2.54mm Vertical | 1 | 秋月電子 | CF25J82RB（114276） | エミッタ帰還（バイパスしない。利得 ≒ 1.5k ÷ 91Ω） |
| R25 | 180 | R Axial DIN0207 L6.3mm D2.5mm P2.54mm Vertical | 1 | 秋月電子 | CF25J180RB（125181） |  |
| R26, R28, R29, R33, R35, R37-R40, R42, R47, R48, R52, R53, R57, R58, R60, R62, R70, R72, R101, R103 | 10k | R Axial DIN0207 L6.3mm D2.5mm P2.54mm Vertical | 22 | 秋月電子 | RD25S 10K（125103） | R35: PTT プルアップ<br>R37: ディエンファシス 470µs<br>R57: VREF = 2.5V |
| R30, R90, R91, R100 | 1M | R Axial DIN0207 L6.3mm D2.5mm P2.54mm Vertical | 4 | 秋月電子 | CF25J1MB（125105） | R30: 自己バイアス<br>R90, R91, R100: 自己バイアス（しきい値 = 入力の平均） |
| R31 | 20k | R Axial DIN0207 L6.3mm D2.5mm P2.54mm Vertical | 1 | 秋月電子 | CF25J20KB（103940） | ダンピング（データシートは 20k）。音が歪むときは 6.8k〜47k で調整 |
| R46 | 470k | R Axial DIN0207 L6.3mm D2.5mm P2.54mm Vertical | 1 | 秋月電子 | RD25S 470K（125474） | ノイズアンプ利得 47 |
| R51, R63, R71 | 100k | R Axial DIN0207 L6.3mm D2.5mm P2.54mm Vertical | 3 | 秋月電子 | CF25J100KB（125104） | R63: 利得 11 |
| R55, R88 | 470 | R Axial DIN0207 L6.3mm D2.5mm P2.54mm Vertical | 2 | 秋月電子 | CF25J470RB（125471） | R55: マイク電源デカップリング<br>R88: 同調 3（14.65MHz）の駆動。Q 約 5 を決める |
| R61 | 220k | R Axial DIN0207 L6.3mm D2.5mm P2.54mm Vertical | 1 | 秋月電子 | CF25J220KB（125224） | マイクアンプ利得 22 |
| R66, R67 | 15k | R Axial DIN0207 L6.3mm D2.5mm P2.54mm Vertical | 2 | 秋月電子 | MFS25F15KB（108552） | R66: 3kHz LPF（サレンキー） |
| R77 | 120 | R Axial DIN0207 L6.3mm D2.5mm P2.54mm Vertical | 1 | 秋月電子 | CF25J120RB（125121） |  |
| R78 | 1.8k | R Axial DIN0207 L6.3mm D2.5mm P2.54mm Vertical | 1 | 秋月電子 | MFS25F1K8B（108538） | ×2 段 1 の遅延 137ns（1.83MHz の 1/4 周期） |
| R79 | 510 | R Axial DIN0207 L6.3mm D2.5mm P2.54mm Vertical | 1 | 秋月電子 | CF25J510RB（125511） | ×2 段 3 の遅延 34ns（7.33MHz の 1/4 周期） |
| R80 | 560 | R Axial DIN0207 L6.3mm D2.5mm P2.54mm Vertical | 1 | 秋月電子 | CF25J560RB（125561） | ベースバイアス（分圧電流 約 12mA、hFE が低くても約 40mA を保つ） |
| R81 | 4.7 | R Axial DIN0207 L6.3mm D2.5mm P2.54mm Vertical | 1 | 秋月電子 | CF25J4R7B（125047） | 帰還（バイパスしない） |
| R82 | 18 | R Axial DIN0207 L6.3mm D2.5mm P2.54mm Vertical | 1 | 秋月電子 | CF25J18RB（114272） | エミッタ電流 約 33mA（2N2222A の損失を 0.25W 程度に） |
| R83 | 47 | R Axial DIN0207 L6.3mm D2.5mm P2.54mm Vertical | 1 | 秋月電子 | CF25J47RB（125470） | 入力スワンプ |
| R86, R92 | 3.3k | R Axial DIN0207 L6.3mm D2.5mm P2.54mm Vertical | 2 | 秋月電子 | CF25J3K3B（125332） |  |
| R93, R94 | 22 | R Axial DIN0414 L11.9mm D4.5mm P5.08mm Vertical | 2 | 秋月電子 | CFS50J22RB（107797） | R93: 入力スワンプ（B）<br>R94: 入力スワンプ（A） |
| R97 | 910 | R Axial DIN0207 L6.3mm D2.5mm P2.54mm Vertical | 1 | 秋月電子 | CF25J910RB（114277） | ×2 段 2 の遅延 68ns（3.66MHz の 1/4 周期） |
| R102 | 47k | R Axial DIN0207 L6.3mm D2.5mm P2.54mm Vertical | 1 | 秋月電子 | CF25J47KB（118208） |  |

**抵抗 R 合計: 103**

## 半固定抵抗 VR

| Reference | 値 / 型番 | フットプリント | 数量 | 購入先 | 購入先の型番（販売コード） | 備考 |
|---|---|---|---|---|---|---|
| VR1, VR3, VR4 | 10k | Potentiometer TOCOS GF063P Vertical | 3 | 秋月電子 | GF063P B103K（114905） | VR1: マイク利得<br>VR3: 周波数偏移（±5kHz に調整）<br>VR4: しきい値の中心（エッジがのこぎり波の中央に来るように） |
| VR2 | 1k | Potentiometer TOCOS GF063P Vertical | 1 | 秋月電子 | GF063P B102K（114901） | のこぎり波の傾き調整（約 260〜430µA） |
| VR5-VR7 | 5k | Potentiometer TOCOS GF063P Vertical | 3 | 秋月電子 | GF063P B502K（114904） | VR5: パルス幅（デューティ 50%）調整<br>VR6: ドライバ IRF510 のアイドル電流（約 150mA。ゲート約 3.5〜4V）<br>VR7: ファイナル IRF510 × 2 のアイドル電流（合計 約 100mA） |

**半固定抵抗 VR 合計: 7**

## コンデンサ C

| Reference | 値 / 型番 | フットプリント | 数量 | 購入先 | 購入先の型番（販売コード） | 備考 |
|---|---|---|---|---|---|---|
| C1, C3, C6, C10, C16-C19, C24, C34, C37-C42, C45, C46, C49, C50, C56, C61, C63, C65, C81, C85, C86, C97, C99, C101, C106, C107, C109, C113, C124 | 0.1u | C Disc D5.0mm W2.5mm P2.50mm | 35 | 秋月電子 | RDER71H104K0P1H03B（113582） | C40: 出力の平滑（出力抵抗 12.5kΩ と約 1.3ms）<br>C42: 差動入力の中点（6 番）の AC 接地<br>C49, C50: データシートどおり VCC へ<br>C106: バイアス点を交流で GND に |
| C2 | 470u | CP Radial D8.0mm P3.50mm | 1 | 秋月電子 | 25PX470MEFC8X11.5（117883） | 25V 以上 |
| C4, C11, C84, C87, C89 | 22p | C Disc D3.0mm W1.6mm P2.50mm | 5 | 秋月電子 | RD15N220J1HL2L（104060） | C4, C11, C87, C89: NP0<br>C84: リセットパルスの時定数（NP0） |
| C5 | 0.33u | C Disc D5.0mm W2.5mm P2.50mm | 1 | 秋月電子 | RD15W334K1HL2L-10（115937） |  |
| C7, C12, C15, C21, C28, C35, C58, C66, C74, C82 | 10u | CP Radial D5.0mm P2.00mm | 10 | 秋月電子 | 50PX10MEFC5X11（117897） | C12: 25V 以上 |
| C8, C20, C22, C25-C27, C29-C33, C43, C47, C53, C54, C62, C90, C93-C96, C98, C100, C108, C110, C123 | 0.01u | C Disc D5.0mm W2.5mm P2.50mm | 26 | 秋月電子 | C8, C22, C26, C27, C29-C33, C43, C47, C53, C54, C62, C90, C93-C96, C98, C100, C108, C110, C123: RD15W103K1HL2L-10（104063）<br>C20, C25: RDE5C1H103J1K1H03B（108043） | C20: フィルム（または C0G）<br>C25: フィルム（または C0G）。積分<br>C27: 負入力を交流で GND へ<br>C30: オフセット補償ループの時定数（データシートの応用回路）<br>C54: DC カット（受信中に入力を GND に落としても出力から電流が流れない） |
| C9 | 2p | C Disc D3.0mm W1.6mm P2.50mm | 1 | 秋月電子 | RDE5C1H2R0C0K1H03B（108044） | NP0、段間結合 |
| C13, C14, C52, C75 | 220p | C Disc D3.0mm W1.6mm P2.50mm | 4 | 秋月電子 | RDE5C1H221J0K1H03B（108106） | C13, C14: PFD のパルスをならす<br>C52: NP0（データシートどおり VCC へ）<br>C75: 高域カット |
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

Notices in the files:
README.md:
このリポジトリのすべて（回路図・基板・部品表・ケースの設計データ、スケッチ、スクリプト、資料）は **GNU General Public License v3.0（GPL-3.0）** で公開しています（[LICENSE](LICENSE)）。改変・再配布するときは、同じ GPL-3.0 で、元の著作権表示とソースを付けてください。
- KiCad 標準の記号・フットプリント（KiCad ライブラリ）は CC-BY-SA 4.0（設計に使う分には例外条項により制約なし）です。プロジェクト独自の記号・フットプリント（`kicad/Serrasoid_TRX.kicad_sym`・`kicad/Serrasoid_TRX.pretty`）は GPL-3.0 です。
- スケッチが使う Etherkit Si5351 ライブラリ（GPL-3.0）・ESP32 Arduino コア（LGPL-2.1）はこのリポジトリに含めていません。各自で入れてください。
